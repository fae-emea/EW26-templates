# IAR project templproj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429II ST STM32F429II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: Inc; Drivers/STM32F4xx_HAL_Driver/Inc; Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; Drivers/CMSIS/Device/ST/STM32F4xx/Include; Drivers/CMSIS/Include; Java_Workspace\VisualState_Demo\VS_Coder
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrafficLight.hex
  ILINK.IlinkOutputFile: TrafficLight.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    Src/: actionFunctions.c gpio.c iar_stm32f429ii_aca.c main.c simpleEventHandler.c startup_stm32f429xx.s stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group HAL
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group VS_Coder/Header Files
    Java_Workspace/VisualState_Demo/VS_Coder/: CSpyLink.h System1.h Workspace.h
  group VS_Coder/Source Files
    Java_Workspace/VisualState_Demo/VS_Coder/: CSpyLink.c System1.c Workspace.c
