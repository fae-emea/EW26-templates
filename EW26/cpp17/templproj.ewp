# IAR project templproj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe550
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: UsingCPlusPlus.srec
  ILINK.IlinkOutputFile: UsingCPlusPlus.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Cpp17demo.cpp
